## tests/example/testcase.yaml
```yaml
tests:
  example.framework_tests:
    platform_allow: native_posix
    tags: framework_tests
```
